# Keil uVision project test.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: piezo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS\CoreSupport;.\CMSIS\DeviceSupport\ST\STM32F10x;.\SPL\src;.\SPL\inc;.\CMSIS;..\тачскрин;.\src;.\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./src/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group SPL
    ./SPL/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_fsmc.c misc.c stm32f10x_exti.c stm32f10x_spi.c
  group Source Files
    ./src/: init.c main.c misc_func.c lcdcmd.c primitives.c oscilloscope.c font.c touch.c sram.c mainmenu.c math_func.c
